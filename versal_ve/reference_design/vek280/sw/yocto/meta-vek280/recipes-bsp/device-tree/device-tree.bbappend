FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
EXTRA_DT_INCLUDE_FILES:linux += "npu_versal.dtsi"

FILESEXTRAPATHS:prepend:versal-vek280-sdt-seg := "${THISDIR}/files:"
SRC_URI:append:versal-vek280-sdt-seg = " file://bootcmd-vek280-sd.cfg"

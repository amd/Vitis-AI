KERNEL_MODULE_AUTOLOAD:append:versal-vek280-sdt-seg = " uio_pdrv_genirq"

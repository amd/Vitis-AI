FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-xlnx:"
SRC_URI:append = "\
    file://u-boot-misc.cfg \
"

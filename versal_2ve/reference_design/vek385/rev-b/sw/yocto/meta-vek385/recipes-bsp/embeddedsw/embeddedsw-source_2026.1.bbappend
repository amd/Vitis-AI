FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-xilpm_ng-xpm_runtime_aie-Remove-AIE-OPs-DDR-range-va.patch"

#RPU-APP owns cortexr52_1 (XSDB ta 5).
BOOTBIN_INC:remove = "libmetal-demo-rpu1.inc"

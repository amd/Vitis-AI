FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://0001-driver-src-global-Add-support-for-more-aie2ps-perf-c.patch"
SRC_URI += " file://0002-driver-src-perfcnt-Support-higher-number-of-perf-cou.patch"
SRC_URI += " file://0003-driver-src-global-Fix-counter-values-for-aie2ps.patch"

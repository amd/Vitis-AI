XEN_ADDITIONAL_INCLUDE = ""
XEN_ADDITIONAL_INCLUDE:versal = "xen-edf.inc"
XEN_ADDITIONAL_INCLUDE:versal-net = "xen-edf.inc"
XEN_ADDITIONAL_INCLUDE:versal-2ve-2vm = "xen-edf.inc"

include ${XEN_ADDITIONAL_INCLUDE}
